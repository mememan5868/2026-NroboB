# Repository mememan5868/2026-NroboB

## KiCad design crc/2026-Node/2026-Node.kicad_pcb

Board: 2 copper layers, 65.2 x 83.4 mm, 48 parts (0 on the bottom side), 22 nets.

Parts:
C1, C4, C5, C7, C10, C11: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3, C8, C9: 20pf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6, C12: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J1, J2, J9, J10: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J3, J5, J11, J13: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J4, J6, J7, J12, J14, J15: Conn_01x04; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J8, J16: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
R1, R5: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R6: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R7: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R8: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2: SW_MEC_5E; SW4_SKRPABE010_ALPS
U1, U5: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
U2, U6: NJM2845DL1-33-TE1; DPAK228P968X238-4N
U3, U4, U7, U8: MCP2561-E-SN; SOIC-8_3.9x4.9mm_P1.27mm
Y1, Y2: Crystal_GND24_Small; XTAL_TSX-3225_25.0000MF10P-C0

Connections:
+3.3V: C5.1, C11.1, J8.6, J16.6, U1.1 (VBAT), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U2.3 (VOUT), U5.1 (VBAT), U5.13 (VDDA), U5.19 (VDD), U5.32 (VDD), U5.48 (VDD), U5.64 (VDD), U6.3 (VOUT)
+5V: C4.1, C10.1, J3.2, J4.2, J5.2, J6.2, J7.2, J11.2, J12.2, J13.2, J14.2, J15.2, U2.1 (VIN), U3.3 (VDD), U4.3 (VDD), U6.1 (VIN), U7.3 (VDD), U8.3 (VDD)
CAN1_H: J1.1, J3.3, J4.3, J5.3, J6.3, J9.1, J11.3, J12.3, J13.3, J14.3, U3.7 (CANH), U7.7 (CANH)
CAN1_L: J3.4, J4.4, J5.4, J6.4, J11.4, J12.4, J13.4, J14.4, R3.2, R7.2, U3.6 (CANL), U7.6 (CANL)
CAN1_RX: U1.44 (PA11), U3.4 (RXD), U5.44 (PA11), U7.4 (RXD)
CAN1_TX: U1.45 (PA12), U3.1 (TXD), U5.45 (PA12), U7.1 (TXD)
CAN2_H: J2.1, J7.3, J10.1, J15.3, U4.7 (CANH), U8.7 (CANH)
CAN2_L: J7.4, J15.4, R4.1, R8.1, U4.6 (CANL), U8.6 (CANL)
CAN2_RX: U1.33 (PB12), U4.4 (RXD), U5.33 (PB12), U8.4 (RXD)
CAN2_TX: U1.34 (PB13), U4.1 (TXD), U5.34 (PB13), U8.1 (TXD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, J3.1, J4.1, J5.1, J6.1, J7.1, J8.4, J11.1, J12.1, J13.1, J14.1, J15.1, J16.4, R2.1, R6.1, SW1.1, SW1.2, SW2.1, SW2.2, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), U2.2 (GND), U3.2 (VSS), U3.8 (STBY), U4.2 (VSS), U4.8 (STBY), U5.12 (VSSA), U5.18 (VSS), U5.31 (VSS), U5.47 (VSS), U5.63 (VSS), U6.2 (GND), U7.2 (VSS), U7.8 (STBY), U8.2 (VSS), U8.8 (STBY), Y1.2 (G), Y1.4 (G), Y2.2 (G), Y2.4 (G)
NRST: J8.2, J16.2, R1.2, R5.2, U1.7 (NRST), U5.7 (NRST)
unnamed: J1.2, J9.2, R3.1, R7.1
unnamed: J2.2, J10.2, R4.2, R8.2
unnamed: C1.1, C7.1, R1.1, R5.1, SW1.3 (K), SW1.4 (A), SW2.3 (K), SW2.4 (A)
unnamed: R2.2, R6.2, U1.60 (BOOT0), U5.60 (BOOT0)
unnamed: C2.1, C8.1, U1.5 (PH0), U5.5 (PH0), Y1.1, Y2.1
unnamed: C3.1, C9.1, U1.6 (PH1), U5.6 (PH1), Y1.3, Y2.3
unnamed: C6.1, C12.1, U1.30 (VCAP_1), U5.30 (VCAP_1)
SWCLK: J8.5, J16.5, U1.49 (PA14), U5.49 (PA14)
SWDIO: J8.3, J16.3, U1.46 (PA13), U5.46 (PA13)
SWO: J8.1, J16.1, U1.55 (PB3), U5.55 (PB3)

File crc/2026-Node/jlcpcb/production_files/BOM-2026-Node.csv:

Comment,Designator,Footprint,LCSC,Quantity
Conn_01x04,J6,JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,,1
20pf,C3,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
R,R4,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
STM32F446RETx,U1,LQFP-64_10x10mm_P0.5mm,,1
NJM2845DL1-33-TE1,U2,DPAK228P968X238-4N,,1
Conn_01x02,J1,PinHeader_1x02_P2.54mm_Vertical,,1
MCP2561-E-SN,U3,SOIC-8_3.9x4.9mm_P1.27mm,,1
0.1uF,C5,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
MCP2561-E-SN,U4,SOIC-8_3.9x4.9mm_P1.27mm,,1
Crystal_GND24_Small,Y1,XTAL_TSX-3225_25.0000MF10P-C0,,1
Conn_01x04,J4,JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,,1
Conn_01x04,J3,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,,1
10k,R2,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
120,R3,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
20pf,C2,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
0.1uF,C4,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
1uF,C6,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
0.1uF,C1,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
470,R1,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
Conn_01x04,J7,JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,,1
SW_MEC_5E,SW1,SW4_SKRPABE010_ALPS,,1
Conn_01x02,J2,PinHeader_1x02_P2.54mm_Vertical,,1
Conn_01x04,J5,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,,1
Conn_01x06,J8,PinHeader_1x06_P2.54mm_Vertical,,1

## KiCad design crc/ISS_MD_SUB/ISS_MD_SUB.kicad_pcb

Board: 2 copper layers, 67.5 x 75.0 mm, 60 parts (6 on the bottom side), 30 nets.

Parts:
C3, C5, C6, C8, C11, C13: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C7, C10, C12: 20pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D4, D5, D6, D7: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J3, J4: Conn_01x04; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J5, J6, J15, J18: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J9, J10: Conn_01x10; PinSocket_1x10_P2.54mm_Vertical
J11, J12: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J13, J16: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J14, J17: Enc; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
R5, R6, R7, R8: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R11, R21, R22, R23, R24, R25, R26, R27, R28: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R14, R15, R16: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R19, R20: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW4, SW6: SW_DIP_x03; SW_DIP_SPSTx03_Slide_9.78x9.8mm_W7.62mm_P2.54mm
SW5, SW7: SW_MEC_5E; SW4_SKRPABE010_ALPS
U2, U3: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
U4, U5: MCP2561-E-SN; SOIC-8_3.9x4.9mm_P1.27mm
U6, U7: NJM2845DL1-33-TE1; DPAK228P968X238-4N
Y2, Y3: Crystal_GND24_Small; XTAL_TSX-3225_25.0000MF10P-C0

Connections:
+3.3V: C11.1, C13.1, J13.6, J16.6, R10.2, R11.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, U2.1 (VDD), U2.5 (VDDA), U2.17 (VDD), U3.1 (VDD), U3.5 (VDDA), U3.17 (VDD), U6.3 (VOUT), U7.3 (VOUT)
+5V: C6.1, C8.1, J3.1, J4.1, J9.7, J10.7, J14.3, J17.3, U4.3 (VDD), U5.3 (VDD), U6.1 (VIN), U7.1 (VIN)
CAN_H: J3.3, J4.3, J11.1, J12.1, U4.7 (CANH), U5.7 (CANH)
CAN_L: J3.4, J4.4, R19.2, R20.2, U4.6 (CANL), U5.6 (CANL)
CAN_RX: U2.21 (PA11), U3.21 (PA11), U4.4 (RXD), U5.4 (RXD)
CAN_TX: U2.22 (PA12), U3.22 (PA12), U4.1 (TXD), U5.1 (TXD)
DirA: J9.1, J10.1, U2.7 (PA1), U3.7 (PA1)
DirB: J9.6, J10.6, U2.6 (PA0), U3.6 (PA0)
EncA: J14.2, J17.2, U2.18 (PA8), U3.18 (PA8)
EncB: J14.4, J17.4, U2.19 (PA9), U3.19 (PA9)
GND: C3.2, C4.1, C5.2, C6.2, C7.1, C8.2, C10.1, C11.2, C12.1, C13.2, D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), J3.2, J4.2, J5.1, J6.1, J9.8, J9.10, J10.8, J10.10, J13.4, J14.1, J15.1, J16.4, J17.1, J18.1, R13.1, R15.1, SW4.4, SW4.5, SW4.6, SW5.1, SW5.2, SW6.4, SW6.5, SW6.6, SW7.1, SW7.2, U2.16 (VSS), U2.32 (VSS), U3.16 (VSS), U3.32 (VSS), U4.2 (VSS), U4.8 (STBY), U5.2 (VSS), U5.8 (STBY), U6.2 (GND), U7.2 (GND), Y2.2 (G), Y2.4 (G), Y3.2 (G), Y3.4 (G)
ID1: R23.1, R27.1, SW4.1, SW6.1, U2.9 (PA3), U3.9 (PA3)
ID2: R10.1, R11.1, SW4.2, SW6.2, U2.10 (PA4), U3.10 (PA4)
ID3: R24.1, R28.1, SW4.3, SW6.3, U2.11 (PA5), U3.11 (PA5)
NRST: J13.2, J16.2, R14.2, R16.2, U2.4 (NRST), U3.4 (NRST)
unnamed: D5.2 (A), D7.2 (A), R5.2, R7.2
unnamed: D4.2 (A), D6.2 (A), R6.2, R8.2
unnamed: J11.2, J12.2, R19.1, R20.1
unnamed: C3.1, C5.1, R14.1, R16.1, SW5.3 (K), SW5.4 (A), SW7.3 (K), SW7.4 (A)
unnamed: R13.2, R15.2, U2.31 (BOOT0), U3.31 (BOOT0)
unnamed: R5.1, R7.1, U2.12 (PA6), U3.12 (PA6)
unnamed: R6.1, R8.1, U2.13 (PA7), U3.13 (PA7)
unnamed: C10.2, C12.2, U2.2 (PF0), U3.2 (PF0), Y2.1, Y3.1
unnamed: C4.2, C7.2, U2.3 (PF1), U3.3 (PF1), Y2.3, Y3.3
PWM: J9.3, J10.3, U2.8 (PA2), U3.8 (PA2)
SWCLK: J13.5, J16.5, U2.24 (PA14), U3.24 (PA14)
SWDIO: J13.3, J16.3, U2.23 (PA13), U3.23 (PA13)
SWO: J13.1, J16.1, U2.26 (PB3), U3.26 (PB3)
sw1: J5.2, J6.2, R21.1, R25.1, U2.29 (PB6), U3.29 (PB6)
sw2: J15.2, J18.2, R22.1, R26.1, U2.30 (PB7), U3.30 (PB7)

File crc/ISS_MD_SUB/jlcpcb/production_files/BOM-ISS_MD_SUB.csv:

Comment,Designator,Footprint,LCSC,Quantity
20pF,C10,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
Conn_01x10,J9,PinSocket_1x10_P2.54mm_Vertical,,1
Conn_01x02,J11,PinHeader_1x02_P2.54mm_Vertical,,1
470,R6,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
10k,R15,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
SW_DIP_x03,SW4,SW_DIP_SPSTx03_Slide_9.78x9.8mm_W7.62mm_P2.54mm,,1
Conn_01x02,J5,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,,1
470,R5,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
Conn_01x02,J6,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,,1
0.1uF,C3,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
Conn_01x02,J12,PinHeader_1x02_P2.54mm_Vertical,,1
0.1uF,C8,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
MCP2561-E-SN,U4,SOIC-8_3.9x4.9mm_P1.27mm,,1
10k,R13,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
0.1uF,C6,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
STM32F303K8Tx,U2,LQFP-32_7x7mm_P0.8mm,,1
STM32F303K8Tx,U3,LQFP-32_7x7mm_P0.8mm,,1
1k,R22,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
20pF,C4,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
LED,D4,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,,1
MCP2561-E-SN,U5,SOIC-8_3.9x4.9mm_P1.27mm,,1
0.1uF,C5,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
120,R19,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
10k,R16,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
Conn_01x04,J4,JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,,1
Enc,J14,JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,,1
Conn_01x04,J3,JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,,1
Conn_01x10,J10,PinSocket_1x10_P2.54mm_Vertical,,1
1k,R11,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
Conn_01x06,J13,PinHeader_1x06_P2.54mm_Vertical,,1
Crystal_GND24_Small,Y2,XTAL_TSX-3225_25.0000MF10P-C0,,1
LED,D5,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,,1
Conn_01x02,J15,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,,1
1k,R21,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
10k,R14,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
NJM2845DL1-33-TE1,U6,DPAK228P968X238-4N,,1
0.1uF,C11,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
SW_MEC_5E,SW5,SW4_SKRPABE010_ALPS,,1
1k,R10,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
1k,R24,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
120,R20,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
1k,R23,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
20pF,C12,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
470,R8,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
SW_DIP_x03,SW6,SW_DIP_SPSTx03_Slide_9.78x9.8mm_W7.62mm_P2.54mm,,1
470,R7,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
1k,R26,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
20pF,C7,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
LED,D6,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,,1
Enc,J17,JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,,1
Conn_01x06,J16,PinHeader_1x06_P2.54mm_Vertical,,1
Crystal_GND24_Small,Y3,XTAL_TSX-3225_25.0000MF10P-C0,,1
LED,D7,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,,1
Conn_01x02,J18,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,,1
1k,R25,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
NJM2845DL1-33-TE1,U7,DPAK228P968X238-4N,,1
0.1uF,C13,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
SW_MEC_5E,SW7,SW4_SKRPABE010_ALPS,,1
1k,R28,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
1k,R27,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1

## KiCad design crc/2026B-main/2026B-main.kicad_pcb

Parts:
C1, C4: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C6: 20pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: CAN1_State; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: CAN2_State; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_ISO7380
J1: USB_B_Mini; USB_Mini-B_Lumberg_2486_01_Horizontal
J2: SWD; PinHeader_1x06_P2.54mm_Vertical
J3, J4, J5, J6: Conn_01x02; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J15, J16, J17, J18: Conn_01x04; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J19: SBUS; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
J20: Lim1_Conn; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
J21: Lim2_Conn; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
J22: Lim3_Conn; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
J23: Lim4_Conn; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
J28, J30: Enc1; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J29, J31: Enc2; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J32: Motor1; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J33: Motor2; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J34: Motor3; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J35: Motor4; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
R1, R2, R5, R6, R7, R8: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R14: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_MEC_5E; SW4_SKRPABE010_ALPS
U1: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
U3, U4: MCP2561-E-SN; SOIC-8_3.9x4.9mm_P1.27mm
U5: NJM2845DL1-33-TE1; DPAK228P968X238-4N; PARTREV 2012-10-31
Y1: Crystal_GND24_Small; XTAL_TSX-3225_25.0000MF10P-C0

Connections:
+3.3V: C2.2, J2.6, R5.2, R6.2, R7.2, R8.2, U1.1 (VBAT), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U5.3 (VOUT)
+5V: C3.1, J1.1 (VBUS), J15.4, J16.4, J17.4, J18.4, J19.2, J28.3, J29.3, J30.3, J31.3, U3.3 (VDD), U4.3 (VDD), U5.1 (VIN)
CAN1_H: J15.2, J16.2, J17.2, J18.2, R3.1, U3.7 (CANH)
CAN1_L: J15.1, J16.1, J17.1, J18.1, R3.2, U3.6 (CANL)
CAN1_RD: U1.44 (PA11), U3.4 (RXD)
CAN1_TD: U1.45 (PA12), U3.1 (TXD)
CAN2_H: J3.2, J4.2, J5.2, J6.2, R4.1, U4.7 (CANH)
CAN2_L: J3.1, J4.1, J5.1, J6.1, R4.2, U4.6 (CANL)
CAN2_RD: U1.33 (PB12), U4.4 (RXD)
CAN2_TD: U1.34 (PB13), U4.1 (TXD)
Dir1: J32.1, U1.53 (PC12)
Dir2: J33.1, U1.54 (PD2)
Dir3: J34.1, U1.56 (PB4)
Dir4: J35.1, U1.57 (PB5)
EncA_1: J28.2, U1.37 (PC6)
EncA_2: J29.2, U1.14 (PA0)
EncA_3: J30.2, U1.42 (PA9)
EncA_4: J31.2, U1.22 (PA6)
EncB_1: J28.4, U1.38 (PC7)
EncB_2: J29.4, U1.15 (PA1)
EncB_3: J30.4, U1.41 (PA8)
EncB_4: J31.4, U1.23 (PA7)
GND1: C1.2, C2.1, C3.2, C4.2, C5.1, C6.1, D1.1 (K), D2.1 (K), J1.5 (GND), J1.SH (Shield), J2.4, J15.3, J16.3, J17.3, J18.3, J19.1, J20.1, J21.1, J22.1, J23.1, J28.1, J29.1, J30.1, J31.1, J32.3, J33.3, J34.3, J35.3, R1.1, SW1.1, SW1.2, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), U3.2 (VSS), U3.8 (STBY), U4.2 (VSS), U4.8 (STBY), U5.2 (GND), Y1.2 (G), Y1.4 (G)
Lim1: J20.2, R5.1, U1.39 (PC8)
Lim2: J21.2, R6.1, U1.16 (PA2)
Lim3: J22.2, R7.1, U1.43 (PA10)
Lim4: J23.2, R8.1, U1.24 (PC4)
NRST: J2.2, R2.2, U1.7 (NRST)
unnamed: D1.2 (A), R13.1
unnamed: D2.2 (A), R14.1
unnamed: C1.1, R2.1, SW1.3 (K), SW1.4 (A)
unnamed: R1.2, U1.60 (BOOT0)
unnamed: R13.2, U1.27 (PB1)
unnamed: R14.2, U1.28 (PB2)
unnamed: C6.2, U1.5 (PH0), Y1.1
unnamed: C5.2, U1.6 (PH1), Y1.3
unnamed: C4.1, U1.30 (VCAP_1)
PWM1: J32.2, U1.58 (PB6)
PWM2: J33.2, U1.59 (PB7)
PWM3: J34.2, U1.61 (PB8)
PWM4: J35.2, U1.62 (PB9)
SBUS_Receive: J19.3, U1.52 (PC11)
SWCLK: J2.5, U1.49 (PA14)
SWDIO: J2.3, U1.46 (PA13)
SWO: J2.1, U1.55 (PB3)

Notes on the sheet:
CAN
ロボマス
電源/SWD
Limit Switch
電源/通信 配信
STM32 F446RET6
Encoder

Board: 2 copper layers, 96.8 x 65.0 mm, 50 parts (0 on the bottom side), 45 nets.

File crc/2026B-main/jlcpcb/production_files/BOM-2026B-main.csv:

Comment,Designator,Footprint,LCSC,Quantity
4.7uF,C2,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
CAN2_State,D2,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,,1
SWD,J2,PinHeader_1x06_P2.54mm_Vertical,,1
Conn_01x02,J6,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,,1
USB_B_Mini,J1,USB_Mini-B_Lumberg_2486_01_Horizontal,,1
0.1uF,C4,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
Conn_01x02,J3,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,,1
SW_MEC_5E,SW1,SW4_SKRPABE010_ALPS,,1
Motor2,J33,JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,,1
Lim3_Conn,J22,JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical,,1
Lim4_Conn,J23,JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical,,1
4.7uF,C3,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
Conn_01x02,J5,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,,1
NJM2845DL1-33-TE1,U5,DPAK228P968X238-4N,,1
SBUS,J19,JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal,,1
Motor3,J34,JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,,1
10k,R5,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
0.1uF,C1,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
Lim1_Conn,J20,JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical,,1
Enc1,J30,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,,1
10k,R7,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
20pF,C5,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
Conn_01x02,J4,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,,1
MCP2561-E-SN,U3,SOIC-8_3.9x4.9mm_P1.27mm,,1
470,R14,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
MCP2561-E-SN,U4,SOIC-8_3.9x4.9mm_P1.27mm,,1
10k,R1,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
Crystal,Y1,XTAL_TSX-3225_25.0000MF10P-C0,,1
Enc2,J31,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,,1
Enc1,J28,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,,1
Conn_01x04,J16,JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,,1
470,R13,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
Lim2_Conn,J21,JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical,,1
Conn_01x04,J15,JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,,1
STM32F446RETx,U1,LQFP-64_10x10mm_P0.5mm,,1
10k,R2,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
Motor1,J32,JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,,1
CAN1_State,D1,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,,1
Conn_01x04,J18,JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,,1
10k,R6,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
Motor4,J35,JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,,1
120,R3,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
10k,R8,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
120,R4,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
Conn_01x04,J17,JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,,1
Enc2,J29,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,,1
20pF,C6,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1

## KiCad design crc/univermain/univermain.kicad_pcb

Parts:
J1, J2, J3, J4: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J9, J10, J11, J12: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
R1, R2: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: NUCLEO-F446RE; MODULE_NUCLEO-F446RE; PARTREV 13
U2, U3: MCP2561-E-P; DIP-8_W7.62mm

Connections:
+5V: J9.1, J11.1, U1.CN7_18 (CN7_+5V), U2.3 (VDD), U3.3 (VDD)
CAN1_H: J1.2, J2.2, J3.2, J4.2, J9.3, J10.3, J11.3, J12.3, R1.2, U2.7 (CANH)
CAN1_L: J1.1, J2.1, J3.1, J4.1, J9.4, J10.4, J11.4, J12.4, R1.1, U2.6 (CANL)
CAN1_RX: U1.CN10_14 (PA11), U2.4 (RXD)
CAN1_TX: U1.CN10_12 (PA12), U2.1 (TXD)
CAN2_H: R2.2, U3.7 (CANH)
CAN2_L: R2.1, U3.6 (CANL)
CAN2_RX: U1.CN10_16 (PB12), U3.4 (RXD)
CAN2_TX: U1.CN10_30 (PB13), U3.1 (TXD)
GND: J9.2, J10.2, J11.2, J12.2, U1.CN7_8 (CN7_GND), U1.CN7_19 (CN7_GND__1), U1.CN7_20 (CN7_GND__2), U1.CN7_22 (CN7_GND__3), U1.CN10_9 (CN10_GND), U1.CN10_20 (CN10_GND__1), U1.CN10_32 (AGND), U2.2 (VSS), U2.8 (STBY), U3.2 (VSS), U3.8 (STBY)

Board: 2 copper layers, 13 parts (0 on the bottom side), 10 nets.
